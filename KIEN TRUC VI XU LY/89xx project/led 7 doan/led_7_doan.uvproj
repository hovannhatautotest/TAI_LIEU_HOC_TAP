# Keil uVision project led_7_doan.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: led_7_doan +hex
  c flags: Optimize=8 SizeSpeed=1
  group New Group
    ./: led_7_doan.c
