ORG 0000H
MAIN:

//sang tu led1 den led8
	MOV P2,#01h
	CALL DELAY
	MOV P2,#03h
	CALL DELAY
	MOV P2,#07h
	CALL DELAY
	MOV P2,#0FH
	CALL DELAY
	MOV P2,#01FH
	CALL DELAY
	MOV P2,#03FH
	CALL DELAY
	MOV P2,#07FH
	CALL DELAY
	MOV P2,#0FFH
	CALL DELAY
////off led 1 den led 8
//	MOV P1,#0FEH
//	CALL DELAY
//	MOV P1,#0FCH
//	CALL DELAY
//	MOV P1,#0F8H
//	CALL DELAY
//	MOV P1,#0F0H
//	CALL DELAY
//	MOV P1,#0E0H
//	CALL DELAY
//	MOV P1,#0C0H
//	CALL DELAY
//	MOV P1,#080H
//	CALL DELAY
//	MOV P1,#00H
//	CALL DELAY
////SANG TU LED 8 DEN LED 1
//	MOV P1,#10000000B
//	CALL DELAY
//	MOV P1,#11000000B
//	CALL DELAY
//	MOV P1,#11100000B
//	CALL DELAY
//	MOV P1,#11110000B
//	CALL DELAY
//	MOV P1,#11111000B
//	CALL DELAY
//	MOV P1,#11111100B
//	CALL DELAY
//	MOV P1,#11111110B
//	CALL DELAY
//	MOV P1,#0FFH
//	CALL DELAY
////TAT LED 8 DEN LED 1
//	MOV P1,#01111111B
//	CALL DELAY
//	MOV P1,#00111111B
//	CALL DELAY
//	MOV P1,#00011111B
//	CALL DELAY
//	MOV P1,#00001111B
//	CALL DELAY
//	MOV P1,#00000111B
//	CALL DELAY
//	MOV P1,#00000011B
//	CALL DELAY
//	MOV P1,#00000001B
//	CALL DELAY
//	MOV P1,#00H
//	CALL DELAY
JMP MAIN
DELAY:
	MOV TMOD,#01H
	MOV TH1,#0FCH
	MOV TL1,#18H
	SETB TR1
	JNB TF1,$
	CLR TR1
	CLR TF1
RET
END