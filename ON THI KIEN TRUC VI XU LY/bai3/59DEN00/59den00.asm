org 00h
	LJMP MAIN
	ORG 30H
	MAIN:
	  CALL CT5900
	  JMP MAIN
CT5900:
	MOV R0,#59
	LAP:
		CALL CTHT
		DEC R0
		CJNE R0,#00,LAP
	RET

CTHT:
	MOV DPTR,#MALED
	MOV R1,#60
	QUET:
		MOV A,R0
		MOV B,#10
		DIV AB
		MOVC A,@A+DPTR
		MOV P2,A
		SETB P3.0
		CALL DELAY
		CLR P3.0
		MOV A,B
		MOVC A,@A+DPTR
		MOV P2,A
		SETB P3.1
		CALL DELAY
		CLR P3.1
		DJNZ R1,QUET
	RET
	
DELAY:
	MOV TMOD,#01H
		MOV TH0,#HIGH(-5000)
		MOV TL0,#LOW(-5000)
		SETB TR0
		JNB TF0,$
		CLR TR0
		CLR TF0
	RET

MALED:
	DB 0C0H,0F9H,0A4H,0B0H,99H,92H,82H,0F8H,80H,90H
end